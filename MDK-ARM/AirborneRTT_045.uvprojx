# Keil uVision project AirborneRTT_045.uvprojx, settings and files
target AirborneRTT_045 (6130001::V6.13.1::.\ARMCLANG)
  device: STM32F407IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: AirborneRTT_045 +hex
  AfterMake: fromelf.exe --bin -o .\bin\@L.bin .\@L\@L.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=4 v6LangP=4 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include; ../RT-Thread; ../Middlewares/Third_Party/RealThread_RTOS_RT-Thread/include/; ../LWIP/App; ../LWIP/Target; ../Middlewares/Third_Party/LwIP/src/include; ../Middlewares/Third_Party/LwIP/system; ../Middlewares/Third_Party/LwIP/src/include/netif/ppp; ../Middlewares/Third_Party/LwIP/src/apps/http; ../Middlewares/Third_Party/LwIP/src/include/lwip; ../Middlewares/Third_Party/LwIP/src/include/lwip/apps; ../Middlewares/Third_Party/LwIP/src/include/lwip/priv; ../Middlewares/Third_Party/LwIP/src/include/lwip/prot; ../Middlewares/Third_Party/LwIP/src/include/netif; ../Middlewares/Third_Party/LwIP/src/include/compat/posix; ../Middlewares/Third_Party/LwIP/src/include/compat/posix/arpa; ../Middlewares/Third_Party/LwIP/src/include/compat/posix/net; ../Middlewares/Third_Party/LwIP/src/include/compat/posix/sys; ../Middlewares/Third_Party/LwIP/src/include/compat/stdc; ../Middlewares/Third_Party/LwIP/system/arch; ..\App\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_eth.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Application/User/LWIP/Target
    ../LWIP/Target/: ethernetif.c
  group Application/User/LWIP/App
    ../LWIP/App/: lwip.c
  group Middlewares/LwIP
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/: auth.c ccp.c chap_ms.c chap-md5.c chap-new.c demand.c eap.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c ecp.c
    ../Middlewares/Third_Party/LwIP/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c slipif.c zepif.c
    ../Middlewares/Third_Party/LwIP/src/apps/http/: httpd.c fs.c
    ../Middlewares/Third_Party/LwIP/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../Middlewares/Third_Party/LwIP/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    ../Middlewares/Third_Party/LwIP/src/apps/mqtt/: mqtt.c
  group Application/User/App
    ../App/Src/: thread_com.c udp_echoserver.c thread_ctrl.c flash.c Parameters.c Senser.c buc.c beacon.c MotorControl.c pwm_api.c Message.c MainDefine.c PID.c CoordinateConvert.c DataAnalysis.c mems.c
  group Middlewares/RT-Thread/RTOS/kernel
    ../Middlewares/Third_Party/RealThread_RTOS_RT-Thread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
    ../Middlewares/Third_Party/RealThread_RTOS_RT-Thread/bsp/: board.c
    ../Middlewares/Third_Party/RealThread_RTOS_RT-Thread/src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c object.c scheduler.c thread.c timer.c
software components: CMSIS:CORE 5.3.0
